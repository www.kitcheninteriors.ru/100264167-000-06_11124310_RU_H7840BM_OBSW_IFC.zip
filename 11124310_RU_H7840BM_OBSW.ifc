Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-07-19T12:30:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 19 12:30:29 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\bbcd61b8-11ea-493b-96e9-8b41475c4d23\789d4a0b-2bf6-4408-b36a-f29a3f8db3b5\ifc * Database version: 5507 * Database creation date: Tue Jul 19 12:30:28 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 19 12:30:29 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 19 12:30:29 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11124310_RU_H7840BM_OBSW:22784026_RU_11124310_H7840BM_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 22784026_RU_11124310_H7840BM_OBSW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 22784026_RU_11124310_H7840BM_OBSW
Type - Pset_ProvisionForVoid - Depth: 562 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm

# IfcDistributionPort, Port_353828
Description: Flow; FlowDirection: SOURCEANDSINK
